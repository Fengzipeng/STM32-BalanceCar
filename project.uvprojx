# Keil uVision project project.uvprojx, settings and files
target project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\StdPeriphDriver\inc;.\Users;.\UCOSII\CODE;.\UCOSII\CONFIG;.\UCOSII\CPU;.\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./Users/: main.c stm32f10x_it.c public.c
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
  group StdPeriphDriver
    ./StdPeriphDriver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group StartUp
    ./StartUp/: startup_stm32f10x_hd.s
  group UCOSII-code
    ./UCOSII/CODE/: os_tmr.c os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group UCOSII-cpu
    ./UCOSII/CPU/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
  group UCOSII-config
    ./UCOSII/CONFIG/: os_cfg.h os_includes.c os_includes.h
  group APP
    ./APP/src/: task.c systick.c led.c printf.c at24cxx.c iic.c key.c flash.c ili9341.c lcd_drive.c
